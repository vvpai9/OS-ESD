# Keil uVision project RTX_Swi.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: RTX_Swi +hex
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Files
    ./: RTX_Swi.c
  group Configuration
    ./: RTX_Config.c Startup.s SWI_Table.s
  group Documentation
    ./: Abstract.txt
